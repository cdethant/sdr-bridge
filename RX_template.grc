options:
  parameters:
    author: ethant
    generate_options: qt_gui
    id: RX_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: sps/samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /data/sdr-bridge/rx_testout.bin
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate * 0.6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: symbol_rate * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    corr0: '12'
    freq0: 433e6
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [digital_gmsk_demod_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
